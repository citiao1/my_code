# Keil uVision project STC32G.uvproj, settings and files
target STC32G12K128_BLDC_HALLESS (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  group startup
    ../../Libraries/libraries/: board.c board.h common.c common.h STC32Gxx.h START251.A51
  group seekfree_libraries
    ../../Libraries/seekfree_peripheral/: headfile.h
    ../../Libraries/seekfree_libraries/: zf_delay.c zf_delay.h zf_pwm.c zf_pwm.h zf_uart.c zf_uart.h zf_gpio.c zf_gpio.h
  group doc
    ../../Libraries/doc/: version.txt
  group user_c
    ../USER/src/: isr.c main.c
  group user_h
    ../USER/inc/: isr.h
  group bldc
    ../../bldc/: comparator.c comparator.h pit_timer.c pit_timer.h battery.c battery.h motor_control.c motor_control.h sine_control.c sine_control.h pwm_out.c pwm_out.h signal_input.c signal_input.h bldc_config.h bldc_version.txt
