# Keil uVision project LQ_MSPM0GX_LIB.uvprojx, settings and files
target LQ_MSPM0G3X_LIB (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LQ_MSPM0GX_LIB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\;..\User;..\Code;..\Code\App;..\Code\Middle;..\Keil;..\TI_SDK;..\TI_SDK\third_party\CMSIS\Core\Include;..\LQ_Lib;..\LQ_Lib\LQ_Common;..\LQ_Lib\LQ_Device;..\LQ_Lib\LQ_Driver;..\TI_SDK\ti
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: ..\User\mspm0g3507.sct
  link misc: ../TI_SDK/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group User
    ../User/: main.c include.h startup_mspm0g350x_uvision.s LQ_isr.c
    ../TI_SDK/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group User_Code
    ../Code/App/: app_debug.c app_scheduler.c
    ../Code/Middle/: mid_beep.c mid_chassis.c mid_encoder.c mid_imu.c mid_key.c mid_line.c mid_motor.c mid_oled.c mid_pid.c
  group LQ_Common
    ../LQ_Lib/LQ_Common/: LQ_enums.h LQ_utils.c LQ_utils.h LQ_common.h LQ_types.h
    ../LQ_Lib/LQ_Device/: LQ_pid.c LQ_pid.h
  group LQ_Device
    ../LQ_Lib/LQ_Device/: LQ_key.c LQ_oled.c LQ_encoder.c LQ_font.c LQ_ccd.c LQ_lsm6dsr.c LQ_mpu6050.c LQ_lsm6dsv16x.c LQ_motor.c LQ_servo.c LQ_1306_motor.c
  group LQ_Driver
    ../LQ_Lib/LQ_Driver/: LQ_adc.c LQ_clock.c LQ_dma.c LQ_exti.c LQ_gpio.c LQ_pwm.c LQ_soft_i2c.c LQ_soft_spi.c LQ_spi.c LQ_time.c LQ_uart.c
  group TI_SKD
    ../TI_SDK/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
