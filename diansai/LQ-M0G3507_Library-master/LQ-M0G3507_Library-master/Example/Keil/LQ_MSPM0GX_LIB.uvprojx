# Keil uVision project LQ_MSPM0GX_LIB.uvprojx, settings and files
target LQ_MSPM0G3X_LIB (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LQ_MSPM0GX_LIB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\;..\User;..\Code;..\Keil;..\TI_SDK;..\TI_SDK\third_party\CMSIS\Core\Include;..\LQ_Lib;..\LQ_Lib\LQ_Common;..\LQ_Lib\LQ_Device;..\LQ_Lib\LQ_Driver;..\TI_SDK\ti;..\Example
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: ..\User\mspm0g3507.sct
  link misc: ../TI_SDK/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group User
    ../User/: main.c include.h startup_mspm0g350x_uvision.s LQ_isr.c
    ../TI_SDK/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group TI_SKD
    ../TI_SDK/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
  group LQ_Device
    ../LQ_Lib/LQ_Device/: LQ_lsm6dsr.c LQ_lsm6dsr.h LQ_device.h LQ_oled.c LQ_oled.h LQ_font.c LQ_font.h LQ_servo.c LQ_servo.h LQ_motor.c LQ_motor.h LQ_tracking.c LQ_tracking.h LQ_encoder.c LQ_encoder.h LQ_pid.c LQ_pid.h LQ_mpu6050.c LQ_mpu6050.h LQ_key.c LQ_key.h LQ_ccd.c LQ_ccd.h
  group LQ_Driver
    ../LQ_Lib/LQ_Driver/: LQ_adc.c LQ_adc.h LQ_clock.c LQ_clock.h LQ_exti.c LQ_exti.h LQ_gpio.c LQ_gpio.h LQ_spi.c LQ_spi.h LQ_time.c LQ_time.h LQ_uart.c LQ_uart.h LQ_soft_i2c.c LQ_soft_i2c.h LQ_soft_spi.c LQ_soft_spi.h LQ_dma.c LQ_dma.h LQ_pwm.c LQ_pwm.h
  group LQ_Common
    ../LQ_Lib/LQ_Common/: LQ_enums.h LQ_utils.c LQ_utils.h LQ_common.h LQ_types.h
  group Example
    ../Example/: LQ_Demo.h 1-LQ_GPIO_Output_Demo.c 2-LQ_GPIO_Input_Demo.c 3-LQ_EXTI_Demo.c 4-LQ_UART_Demo.c 5-LQ_OLED_Demo.c 6-LQ_PWM_Demo.c 7-LQ_TIM_IT_Demo.c 8-LQ_Motor_Demo.c 9-LQ_Servo_Demo.c 10-LQ_Encoder_Demo.c 11-LQ_LSM6DSR_Demo.c 12-LQ_Tracking_Demo.c 13-LQ_MPU6050_Demo.c 14-LQ_CCD_Demo.c 15-LQ_1306Motor_Demo.c
