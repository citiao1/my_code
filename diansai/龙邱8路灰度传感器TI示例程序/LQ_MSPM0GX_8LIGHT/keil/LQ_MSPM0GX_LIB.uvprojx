# Keil uVision project LQ_MSPM0GX_LIB.uvprojx, settings and files
target LQ_MSPM0G3X_LIB (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LQ_MSPM0GX_LIB +hex
  BeforeMake: cmd.exe /C "$P../syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\;..\source;..\source\third_party\CMSIS\Core\Include;..\LQ_device;..\User;..\Code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: ..\source\ti\devices\msp\m0p\linker_files\keil\mspm0g3507.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group User
    ../User/: empty.c
  group Source
    ../source/: include.c include.h
    ../: empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group LQ_device
    ../LQ_device/: LQ_gpio.c LQ_gpio.h LQ_key.c LQ_key.h LQ_oled.c LQ_oled.h LQ_oledfont.c LQ_oledfont.h LQ_encoder.c LQ_encoder.h LQ_motor.c LQ_motor.h LQ_servo.c LQ_servo.h LQ_usart.c LQ_usart.h LQ_lsm6dsr.c LQ_lsm6dsr.h LQ_tracking.c LQ_tracking.h
