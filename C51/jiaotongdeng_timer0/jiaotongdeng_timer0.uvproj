# Keil uVision project jiaotongdeng_timer0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: jiaotongdeng_timer0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51
